## hw/adc/Kconfig
```kconfig
config STM32F2XX_ADC
    bool

config MAX111X
    bool

config RT_LPADC
    bool
```
